# A second minimal technology LEF — ours, written for this test: a different process than
# minimal_tech.lef (its own layer), so a stack of the two needs two technologies.
VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
UNITS
  DATABASE MICRONS 2000 ;
END UNITS
LAYER M1B
  TYPE ROUTING ;
  DIRECTION VERTICAL ;
  PITCH 0.4 ;
  WIDTH 0.2 ;
END M1B
END LIBRARY
